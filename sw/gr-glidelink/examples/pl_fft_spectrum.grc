options:
  parameters:
    author: GlideLink
    description: 'A chain in the PL drawn in GRC (orange PL ports): RF -> NCO -> FFT (the RFNoC FFT block core) -> host port 1. The spectrum of the full-rate signal reaches the PC as one FFT in every KEEP.'
    generate_options: qt_gui
    id: glidelink_pl_fft_spectrum
    output_language: python
    title: GlideLink PL FFT spectrum
  states: {}

blocks:
- name: board
  id: variable
  parameters:
    comment: board with the dsp image (hw/images/dsp.yaml)
    value: '"192.168.3.1"'
  states: {}
- name: args
  id: variable
  parameters:
    value: '"driver=glidelink,uri=ip:" + board'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    comment: the PL runs at this rate; the host port gets samp_rate / keep
    value: 20e6
  states: {}
- name: fft_size
  id: variable
  parameters:
    value: '1024'
  states: {}
- name: scaling
  id: variable
  parameters:
    comment: 'Xilinx FFT schedule, 2 bits per radix-4 stage: shifts 2,2,2,1,1 = 2^-8 (1/N would be 2^-10 and leave weak bins at 0 LSB)'
    value: 2 | 2 << 2 | 2 << 4 | 1 << 6 | 1 << 8
  states: {}
- name: keep
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0,1,1
    label: Keep one FFT in
    rangeType: int
    start: '5'
    step: '1'
    stop: '500'
    value: '40'
  states: {}
- name: nco_freq
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,1,1,1
    label: PL NCO shift (Hz)
    start: '-samp_rate / 2'
    step: 100e3
    stop: samp_rate / 2
    value: '0'
  states: {}
- name: rx_freq
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,0,1,1
    label: RX frequency (Hz)
    start: 70e6
    step: 1e6
    stop: 6e9
    value: 915e6
  states: {}
- name: rx_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,1,1,1
    label: RX gain (dB)
    start: '0'
    step: '1'
    stop: '70'
    value: '30'
  states: {}
- name: radio
  id: glidelink_radio
  parameters:
    address: board
    atten: '89'
    bandwidth: '0'
    gain: rx_gain
    gain_mode: '"manual"'
    rx_freq: rx_freq
    samp_rate: samp_rate
    tx_freq: '0'
  states: {}
- name: nco
  id: glidelink_nco
  parameters:
    args: args
    freq: nco_freq
    phase: '0'
    samp_rate: samp_rate
    slot: '3'
  states: {}
- name: fft
  id: glidelink_fft
  parameters:
    args: args
    bypass: 'False'
    cp_ins: '[]'
    cp_rem: '[]'
    direction: '"forward"'
    keep: keep
    order: '"normal"'
    output: '"complex"'
    scaling: scaling
    size: fft_size
    slot: '1'
  states: {}
- name: host
  id: glidelink_host_source
  parameters:
    args: args
    buffer_length: '65536'
    comment: one FFT per packet
    headers: 'True'
    type: complex
  states: {}
- name: mag2
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: db
  id: blocks_nlog10_ff
  parameters:
    comment: dB relative to full scale (sc16 full scale = 1.0)
    k: '0'
    n: '10'
  states: {}
- name: s2v
  id: blocks_stream_to_vector
  parameters:
    num_items: fft_size
    type: float
  states: {}
- name: spectrum
  id: qtgui_vector_sink_f
  parameters:
    grid: 'True'
    gui_hint: 2,0,8,2
    name: '"Spectrum computed in the PL (RFNoC FFT core)"'
    nconnections: '2'
    label1: '"latest"'
    label2: '"peak hold"'
    vlen: fft_size
    x_axis_label: '"Frequency offset"'
    x_start: '-samp_rate / 2e6'
    x_step: samp_rate / fft_size / 1e6
    x_units: '"MHz"'
    y_axis_label: '"Power"'
    y_units: '"dBFS"'
    ymax: '0'
    ymin: '-100'
  states: {}
- name: peak
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):
          """Peak hold, per bin the maximum of the input vectors, falling by decay_db per vector"""

          def __init__(self, vlen=1024, decay_db=0.05):
              gr.sync_block.__init__(self, name="Peak hold", in_sig=[(np.float32, vlen)], out_sig=[(np.float32, vlen)])
              self.decay_db = decay_db
              self.hold = None

          def work(self, input_items, output_items):
              for k, v in enumerate(input_items[0]):
                  self.hold = v.copy() if self.hold is None else np.maximum(v, self.hold - self.decay_db)
                  output_items[0][k][:] = self.hold
              return len(input_items[0])
    comment: 'bursts of the other board are short (about 8 % of the time): the peak hold shows them'
    decay_db: '0.05'
    vlen: fft_size
  states: {}

connections:
- [radio, '0', nco, '0']
- [nco, '0', fft, '0']
- [fft, '0', host, '0']
- [host, '0', mag2, '0']
- [mag2, '0', db, '0']
- [db, '0', s2v, '0']
- [s2v, '0', spectrum, '0']
- [s2v, '0', peak, '0']
- [peak, '0', spectrum, '1']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
