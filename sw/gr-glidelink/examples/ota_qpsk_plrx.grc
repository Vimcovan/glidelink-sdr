options:
  parameters:
    author: GlideLink
    description: 'QPSK between the two boards at 20 MSPS (5 Msymbol/s), the whole receiver in the PL (qpsk image, hw/images/qpsk.yaml, on both boards): RF -> low-pass and decimation by 2 -> AGC -> FLL band-edge -> RRC matched filter -> symbol sync (Gardner) -> Costas loop -> PC, one sample per symbol. The TX board''s FIR interpolates the PC''s symbols by 4 with an RRC pulse.'
    generate_options: qt_gui
    id: glidelink_ota_qpsk_plrx
    output_language: python
    title: GlideLink OTA QPSK (receiver in the PL)
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    comment: RF sample rate (both boards)
    value: 20e6
  states: {}
- name: sps
  id: variable
  parameters:
    comment: samples per symbol at the RF rate
    value: '4'
  states: {}
- name: decim
  id: variable
  parameters:
    comment: RX decimation in the PL
    value: '2'
  states: {}
- name: rx_sps
  id: variable
  parameters:
    comment: samples per symbol on the PC (RX)
    value: sps // decim
  states: {}
- name: freq
  id: variable
  parameters:
    value: 915e6
  states: {}
- name: qpsk
  id: variable
  parameters:
    value: digital.constellation_qpsk().base()
  states: {}
- name: tx_taps
  id: variable
  parameters:
    comment: 'RRC pulse for the PL interpolation by sps: 11 symbols, gain sps (the zeros of the interpolation), coefficients x 2^14 (FIR shift 14)'
    value: '[int(round(c * 2**14)) for c in firdes.root_raised_cosine(sps, sps, 1.0, 0.35, 11 * sps + 1)]'
  states: {}
- name: rx_taps
  id: variable
  parameters:
    comment: 'low-pass before the PL decimation by 2: 4 MHz, transition 1.5 MHz (the QPSK occupies +-3.375 MHz), coefficients x 2^15 (FIR shift 15)'
    value: '[int(round(c * 2**15)) for c in firdes.low_pass(1.0, samp_rate, 4e6, 1.5e6)]'
  states: {}
- name: tx_atten
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0,1,1
    label: TX attenuation (dB)
    start: '0'
    step: '1'
    stop: '89'
    value: '40'
  states: {}
- name: rx_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,1,1,1
    label: RX gain (dB)
    start: '0'
    step: '1'
    stop: '71'
    value: '40'
  states: {}
- name: bits
  id: analog_random_source_x
  parameters:
    max: '256'
    min: '0'
    num_samps: '10000'
    repeat: 'True'
    type: byte
  states: {}
- name: unpack
  id: blocks_packed_to_unpacked_xx
  parameters:
    bits_per_chunk: '2'
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {}
- name: symbols
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    in_type: byte
    out_type: complex
    symbol_table: qpsk.points()
  states: {}
- name: scale
  id: blocks_multiply_const_vxx
  parameters:
    comment: room for the RRC overshoot
    const: '0.4'
    type: complex
  states: {}
- name: tx
  id: glidelink_sink
  parameters:
    address: '"192.168.4.1"'
    atten: tx_atten
    bandwidth: '0'
    comment: 'symbols (1 per symbol, samp_rate / sps) into the PL: host0_tx'
    freq: freq
    samp_rate: samp_rate
  states: {}
- name: tx_fir
  id: glidelink_fir
  parameters:
    args: '"driver=glidelink,uri=ip:192.168.4.1"'
    comment: interpolation by sps, RRC pulse
    decim: '1'
    interp: sps
    shift: '14'
    slot: '-1'
    taps: tx_taps
  states: {}
- name: tx_radio
  id: glidelink_radio
  parameters:
    address: '"192.168.4.1"'
    atten: tx_atten
    bandwidth: '0'
    comment: TX board RF
    gain: '0'
    gain_mode: '"manual"'
    rx_freq: freq - 10e6
    samp_rate: samp_rate
    tx_freq: freq
  states: {}
- name: rx_radio
  id: glidelink_radio
  parameters:
    address: '"192.168.3.1"'
    atten: '89'
    bandwidth: '0'
    comment: RX board RF
    gain: rx_gain
    gain_mode: '"slow_attack"'
    rx_freq: freq
    samp_rate: samp_rate
    tx_freq: '0'
  states: {}
- name: rx
  id: glidelink_source
  parameters:
    address: '"192.168.3.1"'
    bandwidth: '0'
    comment: 'host0_rx: one sample per symbol (samp_rate / sps) reaches the PC'
    freq: freq
    gain: rx_gain
    gain_mode: '"slow_attack"'
    samp_rate: samp_rate
  states: {}
- name: mf_taps
  id: variable
  parameters:
    comment: RRC matched filter at rx_sps (FIR in slot 4), gain 1, coefficients x 2^15
    value: '[int(round(c * 2**15)) for c in firdes.root_raised_cosine(1.0, rx_sps, 1.0, 0.35, 11 * rx_sps + 1)]'
  states: {}
- name: rx_fir
  id: glidelink_fir
  parameters:
    args: '"driver=glidelink,uri=ip:192.168.3.1"'
    comment: low-pass, decimation by 2 (slot 1)
    decim: decim
    interp: '1'
    shift: '15'
    slot: '1'
    taps: rx_taps
  states: {}
- name: agc
  id: glidelink_agc
  parameters:
    args: '"driver=glidelink,uri=ip:192.168.3.1"'
    gain: '1.0'
    max_gain: '1000.0'
    rate: '1e-3'
    reference: '0.5'
    slot: '-1'
  states: {}
- name: fll
  id: glidelink_fll
  parameters:
    args: '"driver=glidelink,uri=ip:192.168.3.1"'
    filter_size: '44'
    rolloff: '0.35'
    slot: '-1'
    sps: rx_sps
    w: 6.28 / 400
  states: {}
- name: mf
  id: glidelink_fir
  parameters:
    args: '"driver=glidelink,uri=ip:192.168.3.1"'
    comment: RRC matched filter (slot 4, the image's second FIR)
    decim: '1'
    interp: '1'
    shift: '15'
    slot: '4'
    taps: mf_taps
  states: {}
- name: sym
  id: glidelink_symsync
  parameters:
    args: '"driver=glidelink,uri=ip:192.168.3.1"'
    damping: '0.707'
    loop_bw: '0.01'
    max_dev: '0.01'
    slot: '-1'
    ted_gain: '0.3'
  states: {}
- name: costas
  id: glidelink_costas
  parameters:
    args: '"driver=glidelink,uri=ip:192.168.3.1"'
    slot: '-1'
    w: 6.28 / 200
  states: {}
- name: fll_freq
  id: variable_function_probe
  parameters:
    block_id: fll
    comment: FLL frequency register, read once a second
    function_args: '''FREQ'''
    function_name: read
    poll_rate: '1'
    value: '0'
  states: {}
- name: sym_w
  id: variable_function_probe
  parameters:
    block_id: sym
    function_args: '''W'''
    function_name: read
    poll_rate: '1'
    value: 2**23
  states: {}
- name: costas_freq
  id: variable_function_probe
  parameters:
    block_id: costas
    function_args: '''FREQ'''
    function_name: read
    poll_rate: '1'
    value: '0'
  states: {}
- name: fll_khz
  id: variable_qtgui_label
  parameters:
    gui_hint: 1,0,1,1
    label: FLL frequency correction (kHz)
    type: real
    value: ((fll_freq - 2**32) if fll_freq >= 2**31 else fll_freq) / 2**32 * samp_rate / decim / 1e3
  states: {}
- name: sym_ppm
  id: variable_qtgui_label
  parameters:
    gui_hint: 1,1,1,1
    label: Symbol clock vs nominal (ppm, instantaneous)
    type: real
    value: (sym_w / 2**23 - 1) * 1e6
  states: {}
- name: costas_hz
  id: variable_qtgui_label
  parameters:
    gui_hint: 2,0,1,1
    label: Costas residual frequency (Hz)
    type: real
    value: ((costas_freq - 2**32) if costas_freq >= 2**31 else costas_freq) / 2**32 * samp_rate / sps
  states: {}
- name: after
  id: qtgui_const_sink_x
  parameters:
    grid: 'True'
    gui_hint: 3,0,2,2
    name: '"Symbols from the PL receiver (AGC, FLL, matched filter, symbol sync, Costas)"'
    size: '2048'
    type: complex
    xmax: '1'
    xmin: '-1'
    ymax: '1'
    ymin: '-1'
  states: {}

connections:
- [bits, '0', unpack, '0']
- [unpack, '0', symbols, '0']
- [symbols, '0', scale, '0']
- [scale, '0', tx, '0']
- [tx, '0', tx_fir, '0']
- [tx_fir, '0', tx_radio, '0']
- [rx_radio, '0', rx_fir, '0']
- [rx_fir, '0', agc, '0']
- [agc, '0', fll, '0']
- [fll, '0', mf, '0']
- [mf, '0', sym, '0']
- [sym, '0', costas, '0']
- [costas, '0', rx, '0']
- [rx, '0', after, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
