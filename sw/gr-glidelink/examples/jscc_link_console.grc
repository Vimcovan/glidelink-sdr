options:
  parameters:
    author: GlideLink
    description: 'Link console of the offline DeepJSCC-Q system: TX source and attenuation, TX frame and decoded image, link status, receiver constellation and EVM'
    generate_options: qt_gui
    id: jscc_link_console
    output_language: python
    title: GlideLink DeepJSCC-Q link console
  states: {}

blocks:
- name: tx_host
  id: parameter
  parameters:
    comment: TX board (glidelinkd@tx and jscc-tx-app running)
    label: TX board
    short_id: t
    type: str
    value: 192.168.4.1
  states: {}
- name: rx_host
  id: parameter
  parameters:
    comment: RX board (glidelinkd@rx and jscc-rx-app running)
    label: RX board
    short_id: r
    type: str
    value: 192.168.3.1
  states: {}
- name: media
  id: variable
  parameters:
    comment: media directory on the TX board
    value: '''/home/xilinx/claude/tx/media'''
  states: {}
- name: att
  id: variable_qtgui_range
  parameters:
    comment: AD9361 TX attenuation of the TX board (the configuration's default is 4 dB)
    gui_hint: 0,0,1,1
    label: TX attenuation (dB)
    min_len: '300'
    start: '0'
    step: '0.5'
    stop: '70'
    value: '4'
  states: {}
- name: src
  id: variable_qtgui_chooser
  parameters:
    comment: what the TX board encodes and sends
    gui_hint: 0,1,1,1
    label: Source
    labels: '[''Lemons (div2k_0802)'', ''div2k_0801'', ''div2k_0803'', ''div2k_0830'', ''div2k_0843'', ''All presets (cycled)'', ''Video: colorful'', ''Video: kodim23'']'
    num_opts: '0'
    options: '[media + ''/presets/div2k_0802.png'', media + ''/presets/div2k_0801.png'', media + ''/presets/div2k_0803.png'', media + ''/presets/div2k_0830.png'', media + ''/presets/div2k_0843.png'', media + ''/presets'', media + ''/colorful_256.mp4'', media + ''/kodim23_256.mp4'']'
    type: string
    value: media + '/presets/div2k_0802.png'
  states: {}
- name: tx
  id: glidelink_jscc_tx_control
  parameters:
    att: att
    comment: TX application (port 7020)
    host: tx_host
    src: src
  states: {}
- name: view
  id: glidelink_jscc_rx_view
  parameters:
    comment: TX frame | decoded image, status line
    gui_hint: 1,0,1,2
    interval: '1.0'
    rx_host: rx_host
    tx_host: tx_host
    zoom: '2'
  states: {}
- name: syms
  id: glidelink_jscc_rx_symbols
  parameters:
    comment: one frame of the receiver's soft symbols every 2 s (about one image per 2 s is not decoded)
    interval: '2.0'
    rx_host: rx_host
  states: {}
- name: const
  id: qtgui_const_sink_x
  parameters:
    alpha1: '0.5'
    grid: 'True'
    gui_hint: 2,0,1,1
    legend: 'False'
    name: '"Receiver constellation (64-QAM)"'
    size: '8192'
    type: complex
    update_time: '0.5'
    xmax: '1.5'
    xmin: '-1.5'
    ymax: '1.5'
    ymin: '-1.5'
  states: {}
- name: evm
  id: variable_function_probe
  parameters:
    block_id: syms
    comment: EVM of the last symbol frame
    function_name: evm
    poll_rate: '1'
    value: '0'
  states: {}
- name: evm_label
  id: variable_qtgui_label
  parameters:
    formatter: 'lambda x: ''%.2f dB'' % x'
    gui_hint: 2,1,1,1
    label: Receiver EVM (decision directed)
    type: real
    value: evm
  states: {}

connections:
- [syms, '0', const, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
