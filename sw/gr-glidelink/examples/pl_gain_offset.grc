options:
  parameters:
    author: GlideLink
    description: 'The tutorial module (hw/modules/gain_offset, docs/module_guide.md 5) in a PL chain: RF -> NCO -> Gain and offset -> host port 1. Gain and the DC offset change while it runs; the offset shows as a step of I / Q and a line at 0 Hz. Needs the tutorial image.'
    generate_options: qt_gui
    id: glidelink_pl_gain_offset
    output_language: python
    title: GlideLink PL gain and offset
  states: {}

blocks:
- name: board
  id: variable
  parameters:
    comment: board with the tutorial image (python glidelink.py build gain_offset nco --name tutorial)
    value: '"192.168.3.1"'
  states: {}
- name: args
  id: variable
  parameters:
    value: '"driver=glidelink,uri=ip:" + board'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 5e6
  states: {}
- name: gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0,1,1
    label: PL gain
    start: '-2'
    step: '0.01'
    stop: '1.99'
    value: '1'
  states: {}
- name: offset_i
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,1,1,1
    label: PL offset I
    start: '-0.9'
    step: '0.01'
    stop: '0.9'
    value: '0.3'
  states: {}
- name: offset_q
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,1,1,1
    label: PL offset Q
    start: '-0.9'
    step: '0.01'
    stop: '0.9'
    value: '-0.2'
  states: {}
- name: nco_freq
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,0,1,1
    label: PL NCO shift (Hz)
    start: '-samp_rate / 2'
    step: 10e3
    stop: samp_rate / 2
    value: '0'
  states: {}
- name: radio
  id: glidelink_radio
  parameters:
    address: board
    atten: '89'
    bandwidth: '0'
    gain: '40'
    gain_mode: '"manual"'
    rx_freq: 915e6
    samp_rate: samp_rate
    tx_freq: '0'
  states: {}
- name: nco
  id: glidelink_nco
  parameters:
    args: args
    freq: nco_freq
    phase: '0'
    samp_rate: samp_rate
    slot: '-1'
  states: {}
- name: gain_offset
  id: glidelink_gain_offset
  parameters:
    args: args
    comment: generated from hw/modules/gain_offset/module.yaml
    gain: gain
    offset_i: offset_i
    offset_q: offset_q
    slot: '-1'
  states: {}
- name: host
  id: glidelink_host_source
  parameters:
    args: args
    buffer_length: '65536'
    headers: 'True'
    type: complex
  states: {}
- name: time
  id: qtgui_time_sink_x
  parameters:
    entags: 'False'
    grid: 'True'
    gui_hint: 2,0,4,2
    label1: I
    label2: Q
    name: '"After the PL chain"'
    size: '2000'
    srate: samp_rate
    type: complex
  states: {}
- name: spectrum
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: samp_rate
    fc: '0'
    fftsize: '2048'
    grid: 'True'
    gui_hint: 6,0,4,2
    legend: 'False'
    name: '"Spectrum"'
    type: complex
    ymax: '0'
    ymin: '-120'
  states: {}

connections:
- [radio, '0', nco, '0']
- [nco, '0', gain_offset, '0']
- [gain_offset, '0', host, '0']
- [host, '0', time, '0']
- [host, '0', spectrum, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
