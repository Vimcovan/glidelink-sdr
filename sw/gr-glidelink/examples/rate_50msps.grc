options:
  parameters:
    author: GlideLink
    description: 'TX board -> air -> RX board at 50 MSPS through the USB network links (glidelink-streamd UDP streams): two tones and noise sent, the full 50 MHz received and shown; the measured rates are printed every second. For native Windows GNU Radio (radioconda); in WSL the TX rate stays near 48 MSPS (docs/known_issues.md 1.3).'
    generate_options: qt_gui
    id: glidelink_rate_50msps
    output_language: python
    title: GlideLink 50 MSPS
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: 50e6
  states: {}
- name: freq
  id: variable
  parameters:
    value: 915e6
  states: {}
- name: tx_atten
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0,1,1
    label: TX attenuation (dB)
    start: '0'
    step: '1'
    stop: '89'
    value: '40'
  states: {}
- name: rx_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,1,1,1
    label: RX gain (dB)
    start: '0'
    step: '1'
    stop: '70'
    value: '30'
  states: {}
- name: tone1
  id: analog_sig_source_x
  parameters:
    amp: '0.3'
    freq: 10e6
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: tone2
  id: analog_sig_source_x
  parameters:
    amp: '0.2'
    freq: '-15e6'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: noise
  id: analog_noise_source_x
  parameters:
    amp: '0.02'
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: complex
  states: {}
- name: add
  id: blocks_add_xx
  parameters:
    num_inputs: '3'
    type: complex
  states: {}
- name: tx
  id: glidelink_sink
  parameters:
    address: 192.168.4.1
    atten: tx_atten
    bandwidth: '0'
    comment: TX board
    freq: freq
    samp_rate: samp_rate
  states: {}
- name: tx_rate
  id: blocks_probe_rate
  parameters:
    alpha: '0.15'
    mintime: '1000.0'
    type: complex
  states: {}
- name: rx
  id: glidelink_source
  parameters:
    address: 192.168.3.1
    bandwidth: '0'
    comment: RX board
    freq: freq
    gain: rx_gain
    gain_mode: '"manual"'
    samp_rate: samp_rate
  states: {}
- name: rx_rate
  id: blocks_probe_rate
  parameters:
    alpha: '0.15'
    mintime: '1000.0'
    type: complex
  states: {}
- name: rates
  id: blocks_message_debug
  parameters:
    comment: prints the rates (samples per second)
  states: {}
- name: spectrum
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: samp_rate
    fc: freq
    fftsize: '4096'
    grid: 'True'
    gui_hint: 1,0,6,2
    legend: 'False'
    name: '"RX board, 50 MSPS"'
    type: complex
    ymax: '0'
    ymin: '-120'
  states: {}

connections:
- [tone1, '0', add, '0']
- [tone2, '0', add, '1']
- [noise, '0', add, '2']
- [add, '0', tx, '0']
- [add, '0', tx_rate, '0']
- [rx, '0', spectrum, '0']
- [rx, '0', rx_rate, '0']
- [tx_rate, rate, rates, print]
- [rx_rate, rate, rates, print]

metadata:
  file_format: 1
  grc_version: 3.10.9.2
