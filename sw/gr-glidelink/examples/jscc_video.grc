options:
  parameters:
    author: GlideLink
    description: Video from the PC through the offline DeepJSCC-Q link (TX board -> air -> RX board) and back, sent and decoded side by side
    generate_options: qt_gui
    id: glidelink_jscc_video
    output_language: python
    title: GlideLink video link
  states: {}

blocks:
- name: tx_att
  id: variable_qtgui_range
  parameters:
    comment: 'boards about 1 m apart: 8 .. 16 dB is best (below, the receiver is overdriven)'
    gui_hint: 1,0,1,1
    label: TX attenuation (dB)
    start: '0'
    step: '1'
    stop: '60'
    value: '10'
  states: {}
- name: const
  id: qtgui_const_sink_x
  parameters:
    grid: 'True'
    gui_hint: 1,1,2,1
    name: '"Receiver constellation (64-QAM)"'
    size: '8192'
    type: complex
    update_time: '0.5'
    xmax: '1.5'
    xmin: '-1.5'
    ymax: '1.5'
    ymin: '-1.5'
  states: {}
- name: rx
  id: glidelink_jscc_rx_source
  parameters:
    comment: RX board
    host: 192.168.3.1
  states: {}
- name: src
  id: glidelink_video_file_source
  parameters:
    fps: '0'
    path: /mnt/d/ClaudePrj/AD9361/demo_video/edit_v3/demo_v3.mp4
    repeat: 'True'
  states: {}
- name: symbols
  id: glidelink_jscc_rx_symbols
  parameters:
    interval: '2.0'
    rx_host: 192.168.3.1
  states: {}
- name: tx
  id: glidelink_jscc_tx_sink
  parameters:
    att: tx_att
    comment: TX board
    host: 192.168.4.1
  states: {}
- name: video
  id: parameter
  parameters:
    comment: video file on the PC (mp4, avi, mkv, ...), an image, a directory of images or a camera index
    label: Video
    short_id: v
    type: str
    value: ''
  states: {}
- name: view
  id: glidelink_video_sink
  parameters:
    gui_hint: 0,0,1,2
    nconnections: '2'
    zoom: '2'
  states: {}

connections:
- [rx, '0', view, '1']
- [src, '0', tx, '0']
- [src, '0', view, '0']
- [symbols, '0', const, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
