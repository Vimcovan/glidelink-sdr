options:
  parameters:
    author: GlideLink
    description: QPSK from the TX board (GlideLink Sink) to the RX board (GlideLink Source), FLL + clock sync + Costas
    generate_options: qt_gui
    id: glidelink_ota_qpsk
    output_language: python
    title: GlideLink OTA QPSK
  states: {}

blocks:
- name: freq
  id: variable
  parameters:
    value: 915e6
  states: {}
- name: qpsk
  id: variable
  parameters:
    value: digital.constellation_qpsk().base()
  states: {}
- name: rrc_taps
  id: variable
  parameters:
    value: firdes.root_raised_cosine(32, 32 * sps, 1.0, 0.35, 11 * sps * 32)
  states: {}
- name: rx_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,1,1,1
    label: RX gain (dB)
    start: '0'
    step: '1'
    stop: '71'
    value: '40'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '20000000.0'
  states: {}
- name: sps
  id: variable
  parameters:
    value: '4'
  states: {}
- name: tx_atten
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0,1,1
    label: TX attenuation (dB)
    start: '0'
    step: '1'
    stop: '89'
    value: '40'
  states: {}
- name: after
  id: qtgui_const_sink_x
  parameters:
    grid: 'True'
    gui_hint: 2,1,1,1
    name: '"After FLL + clock sync + Costas"'
    size: '1024'
    type: complex
  states: {}
- name: agc
  id: analog_agc_xx
  parameters:
    gain: '1.0'
    max_gain: '65536'
    rate: '1e-3'
    reference: '1.0'
    type: complex
  states: {}
- name: before
  id: qtgui_const_sink_x
  parameters:
    grid: 'True'
    gui_hint: 2,0,1,1
    name: '"Before sync (AGC output)"'
    size: '1024'
    type: complex
  states: {}
- name: bits
  id: analog_random_source_x
  parameters:
    max: '256'
    min: '0'
    num_samps: '10000'
    repeat: 'True'
    type: byte
  states: {}
- name: clock
  id: digital_pfb_clock_sync_xxx
  parameters:
    filter_size: '32'
    init_phase: '16'
    loop_bw: 6.28 / 200
    max_dev: '1.5'
    osps: '1'
    sps: sps
    taps: rrc_taps
    type: ccf
  states: {}
- name: costas
  id: digital_costas_loop_cc
  parameters:
    order: '4'
    w: 6.28 / 200
  states: {}
- name: fll
  id: digital_fll_band_edge_cc
  parameters:
    filter_size: '44'
    rolloff: '0.35'
    samps_per_sym: sps
    type: cc
    w: 6.28 / 400
  states: {}
- name: mod
  id: digital_constellation_modulator
  parameters:
    constellation: qpsk
    differential: 'False'
    excess_bw: '0.35'
    samples_per_symbol: sps
  states: {}
- name: rx
  id: glidelink_source
  parameters:
    address: 192.168.3.1
    bandwidth: '0'
    comment: RX board
    freq: freq
    gain: rx_gain
    gain_mode: '"slow_attack"'
    samp_rate: samp_rate
  states: {}
- name: scale
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.5'
    type: complex
  states: {}
- name: spectrum
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: freq
    fftsize: '2048'
    grid: 'True'
    gui_hint: 1,0,1,1
    name: '"RX spectrum"'
    type: complex
    ymax: '0'
    ymin: '-120'
  states: {}
- name: tx
  id: glidelink_sink
  parameters:
    address: 192.168.4.1
    atten: tx_atten
    bandwidth: '0'
    comment: TX board
    freq: freq
    samp_rate: samp_rate
  states: {}
- name: waterfall
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: freq
    fftsize: '1024'
    gui_hint: 1,1,1,1
    name: '"RX waterfall"'
    type: complex
  states: {}

connections:
- [agc, '0', before, '0']
- [agc, '0', fll, '0']
- [bits, '0', mod, '0']
- [clock, '0', costas, '0']
- [costas, '0', after, '0']
- [fll, '0', clock, '0']
- [mod, '0', scale, '0']
- [rx, '0', agc, '0']
- [rx, '0', spectrum, '0']
- [rx, '0', waterfall, '0']
- [scale, '0', tx, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
