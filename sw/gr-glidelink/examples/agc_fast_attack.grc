options:
  parameters:
    author: GlideLink
    description: Fast AGC lock level changed at run time; the AD9361 is re-initialised and register 0x101 read back
    generate_options: qt_gui
    id: agc_fast_attack
    output_language: python
    title: GlideLink fast AGC
  states: {}

blocks:
- name: uri
  id: parameter
  parameters:
    comment: 'libiio context of the board: ip:192.168.3.1 RX board, ip:192.168.4.1 TX board, local: on the board'
    label: Board
    short_id: u
    type: str
    value: ip:192.168.3.1
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2.5e6
  states: {}
- name: freq
  id: variable
  parameters:
    value: 915e6
  states: {}
- name: lock_level
  id: variable_qtgui_range
  parameters:
    comment: fast AGC lock level, dB below full scale
    gui_hint: 0,0,1,1
    label: Lock level (dBFS below full scale)
    rangeType: int
    start: '5'
    step: '1'
    stop: '30'
    value: '10'
  states: {}
- name: reg101
  id: variable_function_probe
  parameters:
    block_id: ctl
    comment: AD9361 register 0x101 (AGC lock level) read through the control block
    function_args: '''AD9361:0x101'''
    function_name: read
    poll_rate: '2'
    value: '0'
  states: {}
- name: reg101_label
  id: variable_qtgui_label
  parameters:
    formatter: 'lambda x: str(x & 0x7f)'
    gui_hint: 0,1,1,1
    label: Register 0x101 [6:0]
    type: int
    value: reg101
  states: {}
- name: ctl
  id: glidelink_control
  parameters:
    args: '''driver=glidelink,uri='' + uri'
    comment: writes the fast-AGC parameters and re-initialises the AD9361 whenever lock_level changes
    interval: '1.0'
    readback: '[''AD9361:0x101'', ''gain_control_mode'']'
    registers: '{}'
    routes: '{}'
    settings: '{''gain_control_mode'': ''fast_attack'', ''adi,agc-inner-thresh-high'': str(lock_level), ''initialize'': True}'
  states: {}
- name: msg_debug
  id: blocks_message_debug
  parameters:
    comment: prints the control block's read-back
  states: {}
- name: src
  id: soapy_custom_source
  parameters:
    agc0: 'True'
    antenna0: A_BALANCED
    bandwidth0: samp_rate
    center_freq0: freq
    dc_removal0: 'False'
    dev_args: '''uri='' + uri'
    driver: glidelink
    gain0: '0'
    samp_rate: samp_rate
    type: fc32
  states: {}
- name: spectrum
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: samp_rate
    fc: freq
    fftsize: '1024'
    grid: 'True'
    gui_hint: 1,0,1,2
    type: complex
    ymax: '0'
    ymin: '-120'
  states: {}
- name: level
  id: qtgui_time_sink_x
  parameters:
    comment: magnitude of the received samples (the AGC holds the lock level)
    grid: 'True'
    gui_hint: 2,0,1,2
    legend: 'False'
    name: '"|x|"'
    size: '25000'
    srate: samp_rate
    type: float
    ymin: '0'
  states: {}
- name: mag
  id: blocks_complex_to_mag
  parameters: {}
  states: {}

connections:
- [ctl, status, msg_debug, print]
- [src, '0', spectrum, '0']
- [src, '0', mag, '0']
- [mag, '0', level, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
