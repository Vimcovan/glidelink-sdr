options:
  parameters:
    author: GlideLink
    description: 'QPSK between the two boards at 20 MSPS (5 Msymbol/s), the filtering at the full rate in the PL (qpsk image, hw/images/qpsk.yaml, on both boards): the TX board''s FIR interpolates the PC''s symbols by 4 with an RRC pulse, the RX board''s FIR low-passes and decimates by 2, so the PC sends 5 MSPS and receives 10 MSPS (2 samples per symbol) for the FLL, clock sync and Costas loop.'
    generate_options: qt_gui
    id: glidelink_ota_qpsk_pl
    output_language: python
    title: GlideLink OTA QPSK (filters in the PL)
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    comment: RF sample rate (both boards)
    value: 20e6
  states: {}
- name: sps
  id: variable
  parameters:
    comment: samples per symbol at the RF rate
    value: '4'
  states: {}
- name: decim
  id: variable
  parameters:
    comment: RX decimation in the PL
    value: '2'
  states: {}
- name: rx_sps
  id: variable
  parameters:
    comment: samples per symbol on the PC (RX)
    value: sps // decim
  states: {}
- name: freq
  id: variable
  parameters:
    value: 915e6
  states: {}
- name: qpsk
  id: variable
  parameters:
    value: digital.constellation_qpsk().base()
  states: {}
- name: tx_taps
  id: variable
  parameters:
    comment: 'RRC pulse for the PL interpolation by sps: 11 symbols, gain sps (the zeros of the interpolation), coefficients x 2^14 (FIR shift 14)'
    value: '[int(round(c * 2**14)) for c in firdes.root_raised_cosine(sps, sps, 1.0, 0.35, 11 * sps + 1)]'
  states: {}
- name: rx_taps
  id: variable
  parameters:
    comment: 'low-pass before the PL decimation by 2: 4 MHz, transition 1.5 MHz (the QPSK occupies +-3.375 MHz), coefficients x 2^15 (FIR shift 15)'
    value: '[int(round(c * 2**15)) for c in firdes.low_pass(1.0, samp_rate, 4e6, 1.5e6)]'
  states: {}
- name: rrc_taps
  id: variable
  parameters:
    comment: matched filter of the clock sync (32 filters), at rx_sps
    value: firdes.root_raised_cosine(32, 32 * rx_sps, 1.0, 0.35, 11 * rx_sps * 32)
  states: {}
- name: pcores
  id: variable
  parameters:
    comment: 'logical CPUs of the performance cores of this PC (i5-14600KF: 0-11); the FLL and clock sync run about twice as fast there as on an efficiency core (fll_band_edge 16 against 7 MSPS) and need 10 MSPS'
    value: '[2, 3, 4, 5, 6, 7, 8, 9, 10, 11]'
  states: {}
- name: tx_atten
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0,1,1
    label: TX attenuation (dB)
    start: '0'
    step: '1'
    stop: '89'
    value: '40'
  states: {}
- name: rx_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,1,1,1
    label: RX gain (dB)
    start: '0'
    step: '1'
    stop: '71'
    value: '40'
  states: {}
- name: bits
  id: analog_random_source_x
  parameters:
    max: '256'
    min: '0'
    num_samps: '10000'
    repeat: 'True'
    type: byte
  states: {}
- name: unpack
  id: blocks_packed_to_unpacked_xx
  parameters:
    bits_per_chunk: '2'
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {}
- name: symbols
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    in_type: byte
    out_type: complex
    symbol_table: qpsk.points()
  states: {}
- name: scale
  id: blocks_multiply_const_vxx
  parameters:
    comment: room for the RRC overshoot
    const: '0.4'
    type: complex
  states: {}
- name: tx
  id: glidelink_sink
  parameters:
    address: '"192.168.4.1"'
    atten: tx_atten
    bandwidth: '0'
    comment: 'symbols (1 per symbol, samp_rate / sps) into the PL: host0_tx'
    freq: freq
    samp_rate: samp_rate
  states: {}
- name: tx_fir
  id: glidelink_fir
  parameters:
    args: '"driver=glidelink,uri=ip:192.168.4.1"'
    comment: interpolation by sps, RRC pulse
    decim: '1'
    interp: sps
    shift: '14'
    slot: '-1'
    taps: tx_taps
  states: {}
- name: tx_radio
  id: glidelink_radio
  parameters:
    address: '"192.168.4.1"'
    atten: tx_atten
    bandwidth: '0'
    comment: TX board RF
    gain: '0'
    gain_mode: '"manual"'
    rx_freq: freq - 10e6
    samp_rate: samp_rate
    tx_freq: freq
  states: {}
- name: rx_radio
  id: glidelink_radio
  parameters:
    address: '"192.168.3.1"'
    atten: '89'
    bandwidth: '0'
    comment: RX board RF
    gain: rx_gain
    gain_mode: '"slow_attack"'
    rx_freq: freq
    samp_rate: samp_rate
    tx_freq: '0'
  states: {}
- name: rx_fir
  id: glidelink_fir
  parameters:
    args: '"driver=glidelink,uri=ip:192.168.3.1"'
    comment: low-pass, decimation by 2
    decim: decim
    interp: '1'
    shift: '15'
    slot: '-1'
    taps: rx_taps
  states: {}
- name: rx
  id: glidelink_source
  parameters:
    address: '"192.168.3.1"'
    bandwidth: '0'
    comment: 'host0_rx: samp_rate / decim reaches the PC'
    freq: freq
    gain: rx_gain
    gain_mode: '"slow_attack"'
    samp_rate: samp_rate
  states: {}
- name: agc
  id: analog_agc_xx
  parameters:
    gain: '1.0'
    max_gain: '65536'
    rate: '1e-3'
    reference: '1.0'
    type: complex
  states: {}
- name: fll
  id: digital_fll_band_edge_cc
  parameters:
    affinity: pcores
    comment: on the performance cores (variable pcores)
    filter_size: '44'
    rolloff: '0.35'
    samps_per_sym: rx_sps
    type: cc
    w: 6.28 / 400
  states: {}
- name: clock
  id: digital_pfb_clock_sync_xxx
  parameters:
    affinity: pcores
    comment: 'on the performance cores (variable pcores); max_dev 0.05: the two boards'' clocks differ by at most 200 ppm (rate 0.0004 at 2 samples per symbol); 1.5 let the loop settle at the bound (false lock)'
    filter_size: '32'
    init_phase: '16'
    loop_bw: 6.28 / 200
    max_dev: '0.05'
    osps: '1'
    sps: rx_sps
    taps: rrc_taps
    type: ccf
  states: {}
- name: costas
  id: digital_costas_loop_cc
  parameters:
    order: '4'
    w: 6.28 / 200
  states: {}
- name: spectrum
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate / decim
    fc: freq
    fftsize: '2048'
    grid: 'True'
    gui_hint: 1,0,1,1
    name: '"RX spectrum (after the PL decimation)"'
    type: complex
    ymax: '0'
    ymin: '-120'
  states: {}
- name: waterfall
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate / decim
    fc: freq
    fftsize: '1024'
    gui_hint: 1,1,1,1
    name: '"RX waterfall"'
    type: complex
  states: {}
- name: before
  id: qtgui_const_sink_x
  parameters:
    grid: 'True'
    gui_hint: 2,0,1,1
    name: '"Before sync (AGC output)"'
    size: '1024'
    type: complex
  states: {}
- name: after
  id: qtgui_const_sink_x
  parameters:
    grid: 'True'
    gui_hint: 2,1,1,1
    name: '"After FLL + clock sync + Costas"'
    size: '1024'
    type: complex
  states: {}

connections:
- [bits, '0', unpack, '0']
- [unpack, '0', symbols, '0']
- [symbols, '0', scale, '0']
- [scale, '0', tx, '0']
- [tx, '0', tx_fir, '0']
- [tx_fir, '0', tx_radio, '0']
- [rx_radio, '0', rx_fir, '0']
- [rx_fir, '0', rx, '0']
- [rx, '0', agc, '0']
- [rx, '0', spectrum, '0']
- [rx, '0', waterfall, '0']
- [agc, '0', before, '0']
- [agc, '0', fll, '0']
- [fll, '0', clock, '0']
- [clock, '0', costas, '0']
- [costas, '0', after, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
